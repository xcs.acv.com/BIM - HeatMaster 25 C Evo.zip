Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2022-02-09T10:38:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 09 10:38:11 2022 * Host: SMAFTEI-RO-DE * Database: C:\Users\smaftei\AppData\Local\Temp\{CF59EFE6-CFFD-462C-B79A-0666A165B8DD}\ifc * Database version: 5507 * Database creation date: Wed Feb 09 10:38:09 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Feb 09 10:38:09 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 09 10:38:09 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcBoiler: HeatMaster 25 C Evo, HC_Boiler_Condensate Flow_MEPcontent_ACV_HeatMaster 25 C Evo_INT-EN:HeatMaster 25 C Evo:1306498
In: V00
Type - Material: Color RGB 073-073-073, Color RGB 222-222-222, Color RGB 237-028-036, Color RGB 143-145-144, Color RGB 187-080-046, Color RGB 129-158-173
Type - Dimensions - Depth: 708 mm; Domestic Hot Water Diameter 1: 25.4 mm; Domestic Hot Water Diameter 2: 25.4 mm; Flue Gas Diameter: 80 mm; Gas Diameter: 19.05 mm; Height: 1780 mm; Hydronic Supply Diameter: 25.4 mm; Supply Air Diameter: 125 mm; Use Nominal Diameter: yes; Width: 600 mm
Type - Electrical - Current: 0.8 A; Hertz: 50 Hz; Input: 25000 W; Max Power Boiler: 24300 W; Min Power Boiler: 0 W; Rated Current (Fuse): 16 A; Voltage: 230 V
Type - Electrical - Loads - Power: 95 W
Type - Identity Data - Article Type: HeatMaster 25 C Evo; Base Family Version: 22.01; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Floor gas condensing boiler for heating and hot water production; EMCS Version: 4.0; ETIM Article Class: EC011390; Family Version: 22.01; GLN: 5400891000007; Manufacturer: ACV; Manufacturer URL: https://www.acv.com/international; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: HeatMaster 25 C Evo; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Revit Version: 2019; Type Name: HeatMaster 25 C Evo; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Blue: Color RGB 129-158-173; Dark Grey: Color RGB 073-073-073; Glass: Color RGB 218-227-224; Light Grey: Color RGB 143-145-144; Orange Connection: Color RGB 187-080-046; Red: Color RGB 237-028-036; White: Color RGB 222-222-222
Type - Mechanical - DHW Continuous Flow 60°C: 0.000111111 m3/s; Flue Gas Flow: 0 m3/s; Gas Flow Rate Max: 0.000738889 m3/s; Gas Flow Rate Min: 0.000138889 m3/s; Maximum Supply Temperature (Operating Temperature): 87 kg/K/s3; Max Pressure DHW: 860000 Pa; Max Pressure Heating: 300000 Pa; Total Capacity: 0.2 m3; Weight: 177
Type - Other - Category: Mechanical Equipment; A: 1780 mm; B: 600 mm; Bottom Clearance: 0 mm; Chimney Agreement: B23 - B23P - C13(x) - C33(x) - C43(x) - C53(x) - C63(x) - C83(x) - C93(x); Class: 6; F: 150 mm; Family Name: HC_Boiler_Condensate Flow_MEPcontent_ACV_HeatMaster 25 C Evo_INT-EN; Front Clearance: 0 mm; G: 1680 mm; H: 110 mm; K: 1623 mm; L: 1417 mm; M: 1305 mm; O: 458 mm; P: 285 mm; Profile: XXL; Space Heating Energy Efficiency Class: A; Water Heating Energy Efficiency Class: B
Type - Text - Article Description: Floor gas condensing boiler for heating and hot water production; GTIN: 5400891528228; Manufacturer Art. No.: 052822; Product Line: HeatMaster C
Pset_ManufacturerTypeInformation - Manufacturer: ACV
Constraints - Offset: 0 mm
Dimensions - Area: 12.3389 m2; Volume: 0.736169 m3
Identity Data - Mark: 4
Mechanical - Domestic Hot Water Flow 1: 0 m3/s; Domestic Hot Water Flow 2: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow: 0 m3/s; System Classification: Domestic Hot Water,Undefined,Other,Power,Hydronic Supply
Other - Back Clearance Safe: 600 mm; Family: HC_Boiler_Condensate Flow_MEPcontent_ACV_HeatMaster 25 C Evo_INT-EN: HeatMaster 25 C Evo; Family and Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_HeatMaster 25 C Evo_INT-EN: HeatMaster 25 C Evo; Left Clearance Safe: 800 mm; Right Clearance Safe: 400 mm; Top Clearance Safe: 400 mm; Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_HeatMaster 25 C Evo_INT-EN: HeatMaster 25 C Evo; Type Id: HC_Boiler_Condensate Flow_MEPcontent_ACV_HeatMaster 25 C Evo_INT-EN: HeatMaster 25 C Evo
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 600 mm; Left Clearance: 800 mm; Right Clearance: 400 mm; Show Service Area: no; Top Clearance: 400 mm
